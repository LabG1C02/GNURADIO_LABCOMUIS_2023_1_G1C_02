options:
  parameters:
    author: GRUPO_02_G1C
    copyright: UIS
    generate_options: qt_gui
    id: ModuladorAmplitudGNURADIO
    output_language: python
    title: Modulador_AM_GNURADIO
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitud portadora
    start: '-5'
    step: '1'
    stop: '5'
    value: '0.5'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: amplitud mensajera(Am)
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: cambio de bandas
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '100'
    stop: '200000000'
    value: '1000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: gananciaTX
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente de sensibilidad Am(Ka)
    start: '-7'
    step: '0.2'
    stop: '7'
    value: '1'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    rangeType: int
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6/64
  states: {state: disabled}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {state: disabled}
- name: G1C_grupo_02_0
  id: G1C_grupo_02
  parameters:
    Ac: Ac
    Ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/Audio_de_prueba(1).wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    name: '"EnvolventeCompleja"'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"EnvolventeCompleja"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [G1C_grupo_02_0, '0', qtgui_freq_sink_x_0, '0']
- [G1C_grupo_02_0, '0', qtgui_time_sink_x_0, '0']
- [G1C_grupo_02_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', G1C_grupo_02_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', G1C_grupo_02_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
